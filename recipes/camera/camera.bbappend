FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
 
SRC_URI:append = " file://src/"
SRC_URI:append = " file://lib/"
SRC_URI:append = " file://CMakeLists.txt"